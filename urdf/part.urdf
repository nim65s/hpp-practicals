Commit message: [script/gtsp] Use part with less holes.

File: urdf/part.urdf (robot description, URDF)
Before this commit: robot part, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=0.5 0.4 0.4; collision box size=0.5 0.4 0.8
